<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>EndDevice</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Coordinator</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>API</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\icall\zstack.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\icall\zstackconfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\icall\zstackmsg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\icall\server\zstacktask.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\icall\server\zstacktask.h</name>
    </file>
  </group>
  <group>
    <name>CM0_Patch</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\CM0_Patch\apply_patch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\CM0_Patch\apply_zigbee_mce_patch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\CM0_Patch\apply_zigbee_rfe_patch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\CM0_Patch\rfcore_15_4_patch.h</name>
    </file>
  </group>
  <group>
    <name>DBG_TRACE</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\tools\CC26xx_Tracer\dbg.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Target</name>
      <group>
        <name>CC2650</name>
        <group>
          <name>_common</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\_common\cc26xx\mb_PATCH.c</name>
          </file>
        </group>
        <group>
          <name>Config</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_board_cfg.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_mac_cfg.h</name>
          </file>
        </group>
        <group>
          <name>Drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\common\hal_assert.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_trng_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_trng_wrapper.h</name>
          </file>
        </group>
        <group>
          <name>Security</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_ccm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2650TIRTOS\hal_ccm.h</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>MAC</name>
    <group>
      <name>High_Level</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_coord_PATCH.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\include\mac_api.h</name>
      </file>
    </group>
    <group>
      <name>Low_Level</name>
      <group>
        <name>cc26xx</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_assert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_autopend.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_autopend.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_backoff_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_backoff_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_isr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_isr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_low_level.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_low_level.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_mcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_radio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_radio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_radio_defs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_radio_tx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_radio_tx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_rx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_rx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_rx_onoff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_rx_onoff.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_sleep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_tx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\mac_tx.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>NWK</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\AddrMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\APS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_frag.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_groups.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\APSMEDE.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\AssocList.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\BindingTable.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\BindingTable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\NLMEDE.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_bufs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_globals.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_globals.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\reflecttrack.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\rtg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\stub_aps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\stub_aps.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZDiags.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZDiags.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZGlobals.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZGlobals.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\comdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\osal_bufmgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Memory.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_MemoryICall.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\mcu\cc26xx\osal_nv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_PwrMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\osal_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Timers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\ZComDef.h</name>
    </file>
  </group>
  <group>
    <name>Profile</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\af\AF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\af\AF.h</name>
    </file>
  </group>
  <group>
    <name>Security</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp_hash.h</name>
    </file>
  </group>
  <group>
    <name>Services</name>
    <group>
      <name>aes</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\services\aes\zaesccm_api.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\services\aes\zaesccm_cc2650.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\ROM_Support\CommonROM_Init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ICall_startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\osaltasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\cc26xx\ROM_Support\ROM_Init.c</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <group>
      <name>Boundary</name>
      <file>
        <name>$PROJ_DIR$\Config\coreEndDevice.cfg</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Config\coreEndDevice.xcl</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Config\cc26xx_zstack.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC26xx\f8wConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC26xx\f8wCoord.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC26xx\f8wEndev.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC26xx\f8wRouter.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\OnBoard.h</name>
    </file>
  </group>
  <group>
    <name>ZDO</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDApp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDNwkMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDNwkMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDObject.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDObject.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDProfile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDProfile.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDSecMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDSecMgr.h</name>
    </file>
  </group>
  <group>
    <name>ZMac</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\ZMAC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac_cb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac_internal.h</name>
    </file>
  </group>
</project>


