# IAR project ZStackCore.ewp, settings and files
configuration EndDevice (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MODULE_CC26XX_7X7; xZDO_API_ADVANCED; ZDO_API_BASIC; CC26XX; FLASH_ROM_BUILD; USE_ICALL; TC_LINKKEY_JOIN; HAL_ASSERT_SPIN; xHALNODEBUG; xDEBUG; xDEBUG_SW_TRACE; xDBG_ENABLE; OAD_KEEP_NV_PAGES; NV_RESTORE; NV_INIT; FEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; HOLD_AUTO_START; ewarm; NEAR_FUNC=; DATA=
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi; -D_DBGFILE=$FILE_BNAME$_c; -f ..\..\..\Tools\CC26xx\f8wConfig.cfg; -f ..\..\..\Tools\CC26xx\f8wEndev.cfg; -f ..\..\..\Core\Thread\CC26xx\Config\core$CONFIG_NAME$.cfg
  ICCARM.PreInclude: ..\..\..\..\tools\CC26xx_Tracer\dbg.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\tools\CC26xx_Tracer; ..\..\..\common\CC26xx; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\_common\cc26xx; ..\..\..\..\..\Components\hal\target\CC2650TIRTOS; ..\..\..\..\..\Components\icall\include; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\include\cc26xx; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\cc26xx; ..\..\..\..\..\Components\mac\low_level\cc26xx\ROM_Support; ..\..\..\..\..\Components\mac\low_level\cc26xx\CM0_Patch; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\aes; ..\..\..\..\..\Components\services\nv; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\icall; ..\..\..\..\..\Components\stack\icall\client; ..\..\..\..\..\Components\stack\icall\server; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; $DRIVERLIB$\; $DRIVERLIB$\inc; $DRIVERLIB$\driverlib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ZStackCore$CONFIG_NAME$.hex
  postbuild: "$BOUNDARY$\Boundary.exe" -prj "iar" -chip "CC2650" -lcf "Config\cc26xx_zstack.icf" -map "$CONFIG_NAME$\List\ZStackCore$CONFIG_NAME$.map" -xml "Config\boundaryConfig.xml" -cc "Config\core$CONFIG_NAME$.cfg" -lnk "Config\core$CONFIG_NAME$.xcl"
  ILINK.IlinkOutputFile: ZStackCore$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=1; FLASH_ROM_BUILD=1
  ILINK.IlinkIcfFile: Config\cc26xx_zstack.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\Core\Thread\CC26xx\Config\core$CONFIG_NAME$.xcl
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$\driverlib\bin\iar\driverlib.lib; ..\..\..\Libraries\CC26xx\bin\EndDevice.a; ..\..\..\..\..\Projects\common\TIMAC_ROM_Release\03282014\timac_rom_PATCH.symbols
  ILINK.IlinkProgramEntryLabel: startup_entry
configuration Coordinator (ARM, debug)
  as the first configuration, except:
  group API
    ../../../../../Components/stack/icall/: zstack.h zstackconfig.h zstackmsg.h
    ../../../../../Components/stack/icall/server/: zstacktask.c zstacktask.h
  group CM0_Patch
    ../../../../../Components/mac/low_level/cc26xx/CM0_Patch/: apply_patch.h apply_zigbee_mce_patch.h apply_zigbee_rfe_patch.h rfcore_15_4_patch.h
  group DBG_TRACE
    ../../../../tools/CC26xx_Tracer/: dbg.c
  group HAL/Target/CC2650/_common
    ../../../../../Components/hal/target/_common/cc26xx/: mb_PATCH.c
  group HAL/Target/CC2650/Config
    ../../../../../Components/hal/target/CC2650TIRTOS/: hal_board_cfg.h hal_mac_cfg.h
  group HAL/Target/CC2650/Drivers
    ../../../../../Components/hal/common/: hal_assert.c
    ../../../../../Components/hal/target/CC2650TIRTOS/: hal_trng_wrapper.c hal_trng_wrapper.h
  group HAL/Target/CC2650/Security
    ../../../../../Components/hal/target/CC2650TIRTOS/: hal_aes.c hal_aes.h hal_ccm.c hal_ccm.h
  group MAC/High_Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_coord_PATCH.c
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low_Level/cc26xx
    ../../../../../Components/mac/low_level/cc26xx/: mac.c mac.h mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_isr.c mac_isr.h mac_low_level.c mac_low_level.h mac_mcu.c mac_mcu.h mac_radio.c mac_radio.h mac_radio_defs.h mac_radio_tx.c mac_radio_tx.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h osal_bufmgr.h OSAL_Clock.h OSAL_Memory.h OSAL_PwrMgr.h osal_task.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c osal_bufmgr.c OSAL_Clock.c OSAL_MemoryICall.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc26xx/: osal_nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
  group Security
    ../../../../../Components/stack/sec/: ssp.c ssp.h ssp_hash.c ssp_hash.h
  group Services/aes
    ../../../../../Components/services/aes/: zaesccm_api.h zaesccm_cc2650.c
  group Startup
    ../../../../../Components/mac/low_level/cc26xx/ROM_Support/: CommonROM_Init.c ROM_Init.c
    ./: ICall_startup.c osaltasks.c
  group TOOLS
    Config/: cc26xx_zstack.icf
    ../../../Tools/CC26xx/: f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
    ./: OnBoard.c OnBoard.h
  group TOOLS/Boundary
    Config/: coreEndDevice.cfg coreEndDevice.xcl
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
